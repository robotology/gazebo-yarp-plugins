Commit message: Commit equivalent model but working with kdl

File: tutorial/model/double_pendulum/model.urdf (robot description, URDF)
Before this commit: robot double_pendulum, 4 links, 3 joints
Joints:
- joint upper_joint: origin xyz=0 0 2 rpy=1.5708 0 0 -> xyz=0 0 2 rpy=-1.5708 0 0
