Commit message: world interface tutorial tested

File: tutorial/model/worldInterface/model.urdf (robot description, URDF)
Before this commit: robot simple_world_interface, 2 links, 1 joints
Links:
- link base: geometry collision box size=0.20 0.20 0.20; visual box size=0.20 0.20 0.20
